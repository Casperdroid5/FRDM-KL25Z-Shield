# Keil uVision project Analog.uvprojx, settings and files
target KL25Z Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Analog
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: COCK_SETUP=1
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Files
    ./src/: LEDs.c main.c
    ../Software voor SHIELD/OLED/ssd1306/src/: bitmaps.c fonts.c i2c.c ssd1306.c
  group Include Files
    ./inc/: LEDs.h user_defs.h
    ../Software voor SHIELD/OLED/ssd1306/inc/: bitmaps.h fonts.h i2c.h ssd1306.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.5.0
