# Keil uVision project ssd1306.uvprojx, settings and files
target SSD1306-I2C (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ssd1306
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CLOCK_SETUP=1
  c include: ./inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group inc
    ./inc/: i2c.h ssd1306.h bitmaps.h fonts.h
  group src
    ./src/: i2c.c main.c ssd1306.c bitmaps.c fonts.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.5.0
